RDEPENDS:$PN = " neatvnc" 
PACKAGECONFIG:append = " vnc rdp"

