FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://ikconfig-and-evdev.cfg"
